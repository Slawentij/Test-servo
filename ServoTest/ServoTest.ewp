# IAR project ServoTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ; inc\; C:\Program Files (x86)\IAR Systems\Embedded Workbench 6.0\arm\examples\NXP\LPC17xx\LPC1700CMSIS\Drivers\include; inc\board\; inc\IAP\; inc\PWM\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CO2toModBus.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: LPC1768_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: CustomStartUp.s LPC1768_Flash.icf main.c
  group Board
    INC/Board/: board.c
    ./: board.h includes.h
  group PWM
    INC/PWM/: PWM.c PWM.h
